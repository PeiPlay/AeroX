# Keil uVision project AeroX_test.uvprojx, settings and files
target AeroX_test (6210000::V6.21::ARMCLANG)
  device: STM32H723VGTx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.3.1.1
  cpu: IRAM(0x20000000-0x2001FFFF) IRAM2(0x24000000-0x2401FFFF) IROM(0x8000000-0x80FFFFF) CLOCK(12000000) FPU3(DFPU) CPUTYPE("Cortex-M7") ELITTLE TZ
  output: AeroX_test +hex
  c flags: Optim=2 uC99=1 uGnu=1 v6Lang=6 v6LangP=9 wLevel=3
  c define: USE_HAL_DRIVER,STM32H723xx
  c misc: -fexceptions
  c include: ../Core/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc;../Drivers/STM32H7xx_HAL_Driver/Inc/Legacy;../Middlewares/Third_Party/FreeRTOS/Source/include;../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2;../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F;../Drivers/CMSIS/Device/ST/STM32H7xx/Include;../Drivers/CMSIS/Include;../Drivers/CMSIS/DSP;../Project/Attitude;../Project/Attitude/IMU;../Project/Test;../Project/utils/math;../Project/utils/time;../Project/driver;../Project/module;../Project/device;../Project/utils;../Project/utils/memory;../Project/motor;../Project/component;../Project/config;../Project/control;../Project/task;../Project/positioning
  asm include: ../Core/Inc
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x20000
  group Application/MDK-ARM
    ./: startup_stm32h723xx.s
  group Application/User/Core
    ../Core/Src/: main.c gpio.c freertos.c dma.c fdcan.c i2c.c memorymap.c spi.c tim.c usart.c stm32h7xx_it.c stm32h7xx_hal_msp.c stm32h7xx_hal_timebase_tim.c
  group Drivers/STM32H7xx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal_cortex.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hsem.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_mdma.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_exti.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c
  group Drivers/CMSIS
    ../Core/Src/: system_stm32h7xx.c
  group Middlewares/FreeRTOS
    ../Middlewares/Third_Party/FreeRTOS/Source/: croutine.c event_groups.c list.c queue.c stream_buffer.c tasks.c timers.c
    ../Middlewares/Third_Party/FreeRTOS/Source/CMSIS_RTOS_V2/: cmsis_os2.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/MemMang/: heap_4.c
    ../Middlewares/Third_Party/FreeRTOS/Source/portable/RVDS/ARM_CM4F/: port.c
  group Attitude
    ../Project/Attitude/: Attitude.h AttitudeManager.cpp MahonyAHRS.cpp MahonyAHRS.h QuaternionEKF.cpp QuaternionEKF.h
  group Attitude/IMU
    ../Project/Attitude/IMU/: BMI088.cpp BMI088.h BMI088_def.h
  group utils/math
    ../Project/utils/math/: math_angle.c math_angle.h math_bits.c math_bits.h math_common.c math_common.h math_const.h math_matrix.c math_matrix.cpp math_matrix.h math_quaternion.cpp math_quaternion.h math_sort.cpp math_sort.h math_utils.h
  group utils/time
    ../Project/utils/time/: time_delay.cpp time_delay.h time_timestamp.cpp time_timestamp.h time_utils.cpp time_utils.h time_watch.cpp time_watch.h time_timeoutChecker.cpp time_timeoutChecker.h
  group utils/memory
    ../Project/utils/memory/: allocator.h allocator.cpp
  group utils
    ../Project/utils/: utils.h
  group driver
    ../Project/driver/: fdcan_drv.c fdcan_drv.h tim_drv.c tim_drv.h
  group device
    ../Project/device/: ws2812.cpp ws2812.h nrf.cpp nrf.h spl06.cpp spl06.h up_t201.cpp up_t201.h upt20x.cpp upt20x.h lidar.cpp lidar.h hc12.cpp hc12.h
  group module
    ../Project/module/: scheduler.h scheduler.cpp pid.cpp pid.h serial_stream.h watchdog.cpp watchdog.h
  group motor
    ../Project/motor/: motor.cpp motor.h sdc_dual.cpp sdc_dual.h
  group config
    ../Project/config/: config.cpp config.h
  group component
    ../Project/component/: chassis.cpp chassis.h move.cpp move.h
  group test
    ../Project/Test/: test.c test.cpp test.h vofa.cpp vofa.h
  group control
    ../Project/control/: control.cpp control.h control_tunning.cpp control_tunning.h slope_smoother.cpp slope_smoother.h
  group task
    ../Project/task/: taskAttitude.cpp taskManager.c taskManager.h taskStabilize.cpp appCallback.h taskAttitude.h taskManager.cpp taskStabilize.h appCallback.cpp taskCommuCheck.cpp taskCommuCheck.h taskNrfResponse.cpp taskNrfResponse.h taskMovement.cpp taskMovement.h
  group positioning
    ../Project/positioning/: path.cpp path.h point.cpp point.h track.cpp track.h
software components: CMSIS:CORE 5.6.0, CMSIS:DSP 1.15.0, Compiler:I/O:STDERR 1.2.0, Compiler:I/O:STDIN 1.2.0, Compiler:I/O:STDOUT 1.2.0
